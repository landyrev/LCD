# IAR project LCD.ewp, settings and files
configuration LCD Configuration (ARM, debug)
  General.OGChipSelectEditMenu: STM32F205RB ST STM32F205RB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F205xx
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\Drivers\STM32F2xx_HAL_Driver\Inc; ..\..\Drivers\CMSIS\Include; ..\..\Drivers\CMSIS\Device\ST\STM32F2xx\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\Inc
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: LCD Configuration.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group 
    ./: 
  group Application
    ./: 
  group Application/EWARM
    ./: 
    ../../Drivers/CMSIS/Device/ST/STM32F2xx/Source/Templates/iar/: startup_stm32f205xx.s startup_stm32f205xx.s startup_stm32f205xx.s startup_stm32f205xx.s startup_stm32f205xx.s startup_stm32f205xx.s startup_stm32f205xx.s startup_stm32f205xx.s startup_stm32f205xx.s startup_stm32f205xx.s startup_stm32f205xx.s startup_stm32f205xx.s
  group Application/User
    ./: 
    ../../Src/: stm32f2xx_hal_msp.c main.c stm32f2xx_it.c stm32f2xx_hal_msp.c main.c stm32f2xx_it.c stm32f2xx_hal_msp.c main.c stm32f2xx_it.c stm32f2xx_hal_msp.c main.c stm32f2xx_it.c stm32f2xx_hal_msp.c main.c stm32f2xx_it.c stm32f2xx_hal_msp.c main.c stm32f2xx_it.c stm32f2xx_hal_msp.c main.c stm32f2xx_it.c stm32f2xx_hal_msp.c main.c stm32f2xx_it.c stm32f2xx_hal_msp.c main.c stm32f2xx_it.c stm32f2xx_hal_msp.c main.c stm32f2xx_it.c stm32f2xx_hal_msp.c main.c stm32f2xx_it.c stm32f2xx_hal_msp.c main.c stm32f2xx_it.c
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Drivers
    ./: 
  group Drivers/STM32F2xx_HAL_Driver
    ./: 
    ../../Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal_rcc.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_pwr.c stm32f2xx_hal_gpio.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_flash.c stm32f2xx_hal_dma.c stm32f2xx_hal_cortex.c stm32f2xx_hal.c stm32f2xx_hal_rcc.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_pwr.c stm32f2xx_hal_gpio.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_flash.c stm32f2xx_hal_dma.c stm32f2xx_hal_cortex.c stm32f2xx_hal.c stm32f2xx_hal_rcc.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_pwr.c stm32f2xx_hal_gpio.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_flash.c stm32f2xx_hal_dma.c stm32f2xx_hal_cortex.c stm32f2xx_hal.c stm32f2xx_hal_rcc.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_pwr.c stm32f2xx_hal_gpio.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_flash.c stm32f2xx_hal_dma.c stm32f2xx_hal_cortex.c stm32f2xx_hal.c stm32f2xx_hal_rcc.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_pwr.c stm32f2xx_hal_gpio.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_flash.c stm32f2xx_hal_dma.c stm32f2xx_hal_cortex.c stm32f2xx_hal.c stm32f2xx_hal_rcc.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_pwr.c stm32f2xx_hal_gpio.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_flash.c stm32f2xx_hal_dma.c stm32f2xx_hal_cortex.c stm32f2xx_hal.c stm32f2xx_hal_rcc.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_pwr.c stm32f2xx_hal_gpio.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_flash.c stm32f2xx_hal_dma.c stm32f2xx_hal_cortex.c stm32f2xx_hal.c stm32f2xx_hal_rcc.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_pwr.c stm32f2xx_hal_gpio.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_flash.c stm32f2xx_hal_dma.c stm32f2xx_hal_cortex.c stm32f2xx_hal.c stm32f2xx_hal_rcc.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_pwr.c stm32f2xx_hal_gpio.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_flash.c stm32f2xx_hal_dma.c stm32f2xx_hal.c stm32f2xx_hal_cortex.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_rcc.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_spi.c stm32f2xx_hal_pwr.c stm32f2xx_hal_gpio.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_flash.c stm32f2xx_hal_dma.c stm32f2xx_hal_cortex.c stm32f2xx_hal.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_rcc.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_spi.c stm32f2xx_hal_pwr.c stm32f2xx_hal_gpio.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_flash.c stm32f2xx_hal_dma.c stm32f2xx_hal_cortex.c stm32f2xx_hal.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_rcc.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_spi.c stm32f2xx_hal_pwr.c stm32f2xx_hal_gpio.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_flash.c stm32f2xx_hal_dma.c stm32f2xx_hal_cortex.c stm32f2xx_hal.c
  group Drivers/CMSIS
    ./: 
    ../../Drivers/CMSIS/Device/ST/STM32F2xx/Source/Templates/: system_stm32f2xx.c system_stm32f2xx.c system_stm32f2xx.c system_stm32f2xx.c system_stm32f2xx.c system_stm32f2xx.c system_stm32f2xx.c system_stm32f2xx.c system_stm32f2xx.c system_stm32f2xx.c system_stm32f2xx.c system_stm32f2xx.c
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
